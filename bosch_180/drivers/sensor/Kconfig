## bosch_180/drivers/sensor/bmp180/Kconfig
```kconfig
config BMP180
	bool "Bosch BMP180"
	depends on I2C
	help
	  Enable driver for BMP180 sensor.
```
